# Keil uVision project project.uvprojx, settings and files
target TM4C123G (6190000::V6.19::ARMCLANG)
  device: TM4C1231H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wtf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6LangP=1 wLevel=2
  c misc: -Wunused-but-set-variable
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
